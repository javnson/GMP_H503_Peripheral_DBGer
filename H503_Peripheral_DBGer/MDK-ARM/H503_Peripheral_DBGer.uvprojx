# Keil uVision project H503_Peripheral_DBGer.uvprojx, settings and files
target H503_Peripheral_DBGer (6140001::V6.14.1::ARMCLANG)
  device: STM32H503CBUx STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x801FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: H503_Peripheral_DBGer +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H503xx
  c include: ../Core/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../Drivers/CMSIS/Include
  group Application/MDK-ARM
    ./: startup_stm32h503xx.s
  group Application/User/Core
    ../Core/Src/: main.c tpld2001.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_cortex.c stm32h5xx_hal_dac.c stm32h5xx_hal_dac_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_dts.c stm32h5xx_hal_fdcan.c stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_i3c.c stm32h5xx_util_i3c.c stm32h5xx_hal_icache.c stm32h5xx_hal_rtc.c stm32h5xx_hal_rtc_ex.c stm32h5xx_hal_spi.c stm32h5xx_hal_spi_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_pcd.c stm32h5xx_hal_pcd_ex.c stm32h5xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
software components: CMSIS:CORE 4.3.0
